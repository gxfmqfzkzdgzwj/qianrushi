<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_frdmkw019032</project><configuration>Debug</configuration></member><member><project>mqx_frdmkw019032</project><configuration>Release</configuration></member><member><project>MyStarNetworkEndDevice</project><configuration>Debug</configuration></member><member><project>MyStarNetworkEndDevice</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>mqx_frdmkw019032</project><configuration>Debug</configuration></member><member><project>MyStarNetworkEndDevice</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_frdmkw019032</project><configuration>Release</configuration></member><member><project>MyStarNetworkEndDevice</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$_KSDK13_FWK513_PATH_$\lib\ksdk_mqx_lib\iar\KW01Z4\ksdk_mqx_lib.ewp</path></project><project><path>$_KSDK13_FWK513_PATH_$\rtos\mqx\mqx\build\iar\mqx_frdmkw019032\mqx_frdmkw019032.ewp</path></project><project><path>$WS_DIR$/MyStarNetworkEndDevice.ewp</path></project></workspace>
