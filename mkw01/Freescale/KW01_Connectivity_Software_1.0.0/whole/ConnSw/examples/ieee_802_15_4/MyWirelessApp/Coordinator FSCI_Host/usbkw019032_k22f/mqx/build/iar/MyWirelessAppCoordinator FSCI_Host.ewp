# IAR project MyWirelessAppCoordinator FSCI_Host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; IAR; CPU_MK22FN512VMP12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK513_PATH_$/platform/CMSIS/Include; ../../../../../../../../boards/usbkw019032_k22f; $_KSDK13_FWK513_PATH_$/platform/drivers/src/mmcau/asm-cm4; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MK22F51212/include; $_KSDK13_FWK513_PATH_$/platform/devices/MK22F51212/startup; $_KSDK13_FWK513_PATH_$/platform/system/src/clock/MK22F51212; ../../../../../../../../ieee_802_15_4/Source/App; ../../../../../../../../ieee_802_15_4/Source/Mac/Interface; ../../../../../../../../framework/GPIOIrq; ../../../../../../../../framework/Keyboard/Interface; ../../../../../../../../framework/LED/Interface; ../../../../../../../../framework/SerialManager/Source/SPI_Adapter; ../../../../../../../../framework/FSCI/Interface; ../../../../../../../../framework/FSCI/Source; ../../../../../../../../framework/Common; ../../../../../../../../framework/MemManager/Interface; ../../../../../../../../framework/Messaging/Interface; ../../../../../../../../framework/OSAbstraction/Interface; $_KSDK13_FWK513_PATH_$/platform/osa/inc; ../../../../../../../../framework/Panic/Interface; ../../../../../../../../framework/RNG/Interface; ../../../../../../../../framework/SerialManager/Interface; ../../../../../../../../framework/SerialManager/Source/USB_VirtualCom; $_KSDK13_FWK513_PATH_$/usb/adapter/sources; $_KSDK13_FWK513_PATH_$/usb/adapter/sources/sdk; $_KSDK13_FWK513_PATH_$/usb/usb_core/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/include/MK22F51212; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/include/config; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/cdc; ../../../../../../../../framework/TimersManager/Interface; ../../../../../../../../framework/TimersManager/Source; ../../../../../../../../framework/FunctionLib; ../../../../../../../../framework/Lists; ../../../../../../../../framework/SecLib; ../../../../../../../../framework/ModuleInfo; ../../../../common; $_KSDK13_FWK513_PATH_$/rtos/mqx/config/common; $_KSDK13_FWK513_PATH_$/rtos/mqx/mqx/source/include; $_KSDK13_FWK513_PATH_$/rtos/mqx/lib/usbkw019032_k22f.iar/debug/config; $_KSDK13_FWK513_PATH_$/rtos/mqx/lib/usbkw019032_k22f.iar/debug/mqx; $_KSDK13_FWK513_PATH_$/rtos/mqx/mqx/source/bsp; $_KSDK13_FWK513_PATH_$/platform/drivers/inc; $_KSDK13_FWK513_PATH_$/platform/system/inc; $_KSDK13_FWK513_PATH_$/platform/hal/inc; $_KSDK13_FWK513_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: MyWirelessAppCoordinator FSCI_Host.bin
  ILINK.IlinkOutputFile: MyWirelessAppCoordinatorFSCI_Host_MQX.out
  ILINK.IlinkConfigDefines: __heap_size__=12000
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MK22F51212/linker/iar/MK22FN512xxx12_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\usb\usb_core\device\lib\mqx\iar\MK22F51212\debug\libusbd_mqx.a; ../../../../../../../../framework/SecLib/lib_crypto_IAR_M4.a; $_KSDK13_FWK513_PATH_$\lib\ksdk_mqx_lib\iar\K22F51212\debug\libksdk_platform_mqx.a; $_KSDK13_FWK513_PATH_$\rtos\mqx\lib\usbkw019032_k22f.iar\debug\mqx\lib_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MK22FN512VMP12
  ICCARM.CCIncludePath2: $_KSDK13_FWK513_PATH_$/platform/CMSIS/Include; ../../../../../../../../boards/usbkw019032_k22f; $_KSDK13_FWK513_PATH_$/platform/drivers/src/mmcau/asm-cm4; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MK22F51212/include; $_KSDK13_FWK513_PATH_$/platform/devices/MK22F51212/startup; $_KSDK13_FWK513_PATH_$/platform/system/src/clock/MK22F51212; ../../../../../../../../ieee_802_15_4/Source/App; ../../../../../../../../ieee_802_15_4/Source/Mac/Interface; ../../../../../../../../framework/GPIOIrq; ../../../../../../../../framework/Keyboard/Interface; ../../../../../../../../framework/LED/Interface; ../../../../../../../../framework/SerialManager/Source/SPI_Adapter; ../../../../../../../../framework/FSCI/Interface; ../../../../../../../../framework/FSCI/Source; ../../../../../../../../framework/Common; ../../../../../../../../framework/MemManager/Interface; ../../../../../../../../framework/Messaging/Interface; ../../../../../../../../framework/OSAbstraction/Interface; $_KSDK13_FWK513_PATH_$/platform/osa/inc; ../../../../../../../../framework/Panic/Interface; ../../../../../../../../framework/RNG/Interface; ../../../../../../../../framework/SerialManager/Interface; ../../../../../../../../framework/SerialManager/Source/USB_VirtualCom; $_KSDK13_FWK513_PATH_$/usb/adapter/sources; $_KSDK13_FWK513_PATH_$/usb/adapter/sources/sdk; $_KSDK13_FWK513_PATH_$/usb/usb_core/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/include/MK22F51212; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/include; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/include/config; $_KSDK13_FWK513_PATH_$/usb/usb_core/device/sources/classes/cdc; ../../../../../../../../framework/TimersManager/Interface; ../../../../../../../../framework/TimersManager/Source; ../../../../../../../../framework/FunctionLib; ../../../../../../../../framework/Lists; ../../../../../../../../framework/SecLib; ../../../../../../../../framework/ModuleInfo; ../../../../common; $_KSDK13_FWK513_PATH_$/rtos/mqx/config/common; $_KSDK13_FWK513_PATH_$/rtos/mqx/mqx/source/include; $_KSDK13_FWK513_PATH_$/rtos/mqx/lib/usbkw019032_k22f.iar/release/config; $_KSDK13_FWK513_PATH_$/rtos/mqx/lib/usbkw019032_k22f.iar/release/mqx; $_KSDK13_FWK513_PATH_$/rtos/mqx/mqx/source/bsp; $_KSDK13_FWK513_PATH_$/platform/drivers/inc; $_KSDK13_FWK513_PATH_$/platform/system/inc; $_KSDK13_FWK513_PATH_$/platform/hal/inc; $_KSDK13_FWK513_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\usb\usb_core\device\lib\mqx\iar\MK22F51212\release\libusbd_mqx.a; ../../../../../../../../framework/SecLib/lib_crypto_IAR_M4.a; $_KSDK13_FWK513_PATH_$\lib\ksdk_mqx_lib\iar\K22F51212\release\libksdk_platform_mqx.a; $_KSDK13_FWK513_PATH_$\rtos\mqx\lib\usbkw019032_k22f.iar\release\mqx\lib_mqx.a
  group framework/Common
    ../../../../../../../../framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/FSCI/Interface
    ../../../../../../../../framework/FSCI/Interface/: FsciInterface.h
  group framework/FSCI/Source
    ../../../../../../../../framework/FSCI/Source/: FsciCommands.c FsciCommands.h FsciCommunication.c FsciCommunication.h FsciLogging.c FsciMain.c
  group framework/FunctionLib
    ../../../../../../../../framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIOIrq/Interface
    ../../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../../../../framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../../framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../../framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../../framework/LED/Source/: LED.c
  group framework/Lists
    ../../../../../../../../framework/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    ../../../../../../../../framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../../framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    ../../../../../../../../framework/ModuleInfo/: ModuleInfo.h
  group framework/OSAbstraction/Interface
    ../../../../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/OSAbstraction/Source
    ../../../../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_mqx.c
  group framework/Panic/Interface
    ../../../../../../../../framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../../framework/Panic/Source/: Panic.c
  group framework/Reset/Source
    ../../../../../../../../framework/Reset/: Reset.c
  group framework/RNG/Interface
    ../../../../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../../framework/RNG/Source/: RNG.c
  group framework/SecLib
    ../../../../../../../../framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    ../../../../../../../../framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    ../../../../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../../framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/SerialManager/Source/USB_VirtualCom/Interface
    ../../../../../../../../framework/SerialManager/Source/USB_VirtualCom/: usb_descriptor.h virtual_com.h VirtualComInterface.h
  group framework/SerialManager/Source/USB_VirtualCom/Source
    ../../../../../../../../framework/SerialManager/Source/USB_VirtualCom/: usb_descriptor.c virtual_com.c
  group framework/TimersManager/Interface
    ../../../../../../../../framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group ieee_802.15.4/App
    ../../../../../../../../ieee_802_15_4/Source/App/: FsciMacCommands.c FsciMacCommands.h MacGlobals.c MacGlobals.h
  group ieee_802.15.4/Mac/Interface
    ../../../../../../../../ieee_802_15_4/Source/Mac/Interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group KSDK
    ../../../../../../../../boards/usbkw019032_k22f/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group RTOS/MQX/BSP Files
    $_KSDK13_FWK513_PATH_$/rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group RTOS/MQX/Config Files
    $_KSDK13_FWK513_PATH_$/rtos/mqx/config/mcu/MK22F51212/: mqx_sdk_config.h
    $_KSDK13_FWK513_PATH_$/rtos/mqx/config/board/usbkw019032_k22f/: user_config.h
  group RTOS/MQX/Config Files/Common
    $_KSDK13_FWK513_PATH_$/rtos/mqx/config/common/: lite_config.h mqx_cnfg.h small_ram_config.h verif_enabled_config.h
  group Source
    ../../../../common/: App.c App.h
    ../../: app_preinclude.h
