<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>usbd_sdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>usbd_sdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_usbkw019032_k22f</project><configuration>Debug</configuration></member><member><project>mqx_usbkw019032_k22f</project><configuration>Release</configuration></member><member><project>MyWirelessAppEndDevice FSCI_Host</project><configuration>Debug</configuration></member><member><project>MyWirelessAppEndDevice FSCI_Host</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>usbd_sdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>mqx_usbkw019032_k22f</project><configuration>Debug</configuration></member><member><project>MyWirelessAppEndDevice FSCI_Host</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>usbd_sdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>mqx_usbkw019032_k22f</project><configuration>Release</configuration></member><member><project>MyWirelessAppEndDevice FSCI_Host</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$_KSDK13_FWK513_PATH_$\usb\usb_core\device\lib\mqx\iar\MK22F51212\usbd_sdk_mqx_lib.ewp</path></project><project><path>$_KSDK13_FWK513_PATH_$\lib\ksdk_mqx_lib\iar\K22F51212\ksdk_mqx_lib.ewp</path></project><project><path>$_KSDK13_FWK513_PATH_$\rtos\mqx\mqx\build\iar\mqx_usbkw019032_k22f\mqx_usbkw019032_k22f.ewp</path></project><project><path>$WS_DIR$/MyWirelessAppEndDevice FSCI_Host.ewp</path></project></workspace>
