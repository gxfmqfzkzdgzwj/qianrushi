# IAR project MAC_LE_DemoEndDevice.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW01Z128xxx4 Freescale MKW01Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; IAR; CPU_MKW01Z128CHN4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.PreInclude: ../../app_preinclude.h
  ICCARM.CCIncludePath2: $_KSDK13_FWK513_PATH_$/platform/CMSIS/Include; ../../../../../../../../boards/usbkw019032_kw01; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/include; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup; $_KSDK13_FWK513_PATH_$/platform/system/src/clock/MKW01Z4; $_KSDK13_FWK513_PATH_$/platform/devices; $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup; ../../../../../../../../ieee_802_15_4/Source/App; ../../../../../../../../ieee_802_15_4/Source/Mac/Interface; ../../../../../../../../ieee_802_15_4/Source/Phy/Interface; ../../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x; ../../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/SX123xDrv; ../../../../../../../../ieee_802_15_4/Source/Phy/Source/XcvrSpi; ../../../../../../../../framework/GPIOIrq; ../../../../../../../../framework/Keyboard/Interface; ../../../../../../../../framework/LED/Interface; ../../../../../../../../framework/SerialManager/Source/SPI_Adapter; ../../../../../../../../framework/Common; ../../../../../../../../framework/MemManager/Interface; ../../../../../../../../framework/Messaging/Interface; ../../../../../../../../framework/OSAbstraction/Interface; $_KSDK13_FWK513_PATH_$/platform/osa/inc; ../../../../../../../../framework/Panic/Interface; ../../../../../../../../framework/RNG/Interface; ../../../../../../../../framework/SerialManager/Interface; ../../../../../../../../framework/TimersManager/Interface; ../../../../../../../../framework/TimersManager/Source; ../../../../../../../../framework/FunctionLib; ../../../../../../../../framework/Lists; ../../../../../../../../framework/SecLib; ../../../../../../../../framework/ModuleInfo; ../../../../../../../../framework/LowPower/Interface/KW0xZ; ../../../../common; $_KSDK13_FWK513_PATH_$/platform/drivers/inc; $_KSDK13_FWK513_PATH_$/platform/system/inc; $_KSDK13_FWK513_PATH_$/platform/hal/inc; $_KSDK13_FWK513_PATH_$/platform/utilities/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: generic.bin
  ILINK.IlinkOutputFile: MAC_LE_DemoEndDevice_BM.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MKW01Z4/linker/iar/MKW01Z128xxx4_connectivity.icf
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\lib\ksdk_platform_lib\iar\KW01Z4\debug\libksdk_platform.a; ../../../../../../../../ieee_802_15_4/Lib/Freescale_802.15.4_MAC_06eLEg_M0_IAR.a; ../../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; CPU_MKW01Z128CHN4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: $_KSDK13_FWK513_PATH_$\lib\ksdk_platform_lib\iar\KW01Z4\release\libksdk_platform.a; ../../../../../../../../ieee_802_15_4/Lib/Freescale_802.15.4_MAC_06eLEg_M0_IAR.a; ../../../../../../../../framework/SecLib/lib_crypto_IAR_M0.a
  group framework/OSAbstraction/Source
    ../../../../../../../../framework/OSAbstraction/Source/: fsl_osa_ext_bm.c
  group framework/OSAbstraction/Interface
    ../../../../../../../../framework/OSAbstraction/Interface/: fsl_osa_ext.h fsl_osa_ext_config.h
  group framework/GPIOIrq/Interface
    ../../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.h
  group framework/GPIOIrq/Source
    ../../../../../../../../framework/GPIOIrq/: GPIO_IrqAdapter.c
  group framework/Keyboard/Interface
    ../../../../../../../../framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    ../../../../../../../../framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    ../../../../../../../../framework/LED/Interface/: LED.h
  group framework/LED/Source
    ../../../../../../../../framework/LED/Source/: LED.c
  group framework/Reset/Source
    ../../../../../../../../framework/Reset/: Reset.c
  group framework/SerialManager/Source
    ../../../../../../../../framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/SPI_Adapter
    ../../../../../../../../framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.h SPI_Adapter.c
  group framework/SerialManager/Interface
    ../../../../../../../../framework/SerialManager/Interface/: SerialManager.h
  group framework/Common
    ../../../../../../../../framework/Common/: EmbeddedTypes.h FwkInit.c
  group framework/MemManager/Interface
    ../../../../../../../../framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    ../../../../../../../../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../../../../../../../../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../../../../../../../../framework/Messaging/Source/: Messaging.c
  group framework/Panic/Interface
    ../../../../../../../../framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    ../../../../../../../../framework/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../../../../../../../../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../../../../../../../../framework/RNG/Source/: RNG.c
  group framework/TimersManager/Interface
    ../../../../../../../../framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    ../../../../../../../../framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.h TMR_Adapter.c
  group framework/FunctionLib
    ../../../../../../../../framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Lists
    ../../../../../../../../framework/Lists/: GenericList.c GenericList.h
  group framework/ModuleInfo
    ../../../../../../../../framework/ModuleInfo/: ModuleInfo.h
  group framework/SecLib
    ../../../../../../../../framework/SecLib/: SecLib.h SecLib.c
  group framework/LowPower/Interface
    ../../../../../../../../framework/LowPower/Interface/KW0xZ/: PWR_Configuration.h PWR_Interface.h
  group framework/LowPower/Source
    ../../../../../../../../framework/LowPower/Source/KW0xZ/: PWR.c PWRLib.c PWRLib.h
  group RTOS/Startup
    $_KSDK13_FWK513_PATH_$/platform/devices/: startup.c startup.h
    $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup/iar/: startup_MKW01Z4.s
    $_KSDK13_FWK513_PATH_$/platform/devices/MKW01Z4/startup/: system_MKW01Z4.c system_MKW01Z4.h
  group ieee_802.15.4/App
    ../../../../../../../../ieee_802_15_4/Source/App/: FsciMacCommands.h FsciMacCommands.c MacGlobals.c MacGlobals.h
  group ieee_802.15.4/Mac/Interface
    ../../../../../../../../ieee_802_15_4/Source/Mac/Interface/: MacFunctionalityDefines.h MacInterface.h MacMessages.h MacTypes.h
  group ieee_802.15.4/PHY/Interface
    ../../../../../../../../ieee_802_15_4/Source/Phy/Interface/: AspInterface.h MpmInterface.h PhyDebug.h PhyInterface.h PhyMessages.h PhyTypes.h
  group ieee_802.15.4/PHY/Source/MKW0x
    ../../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/: ASP.c Phy.h PhyDebug.c PhyExtended.c PhyExtended.h PhyISR.c PhyISR.h PhyPib.c PhyPib.h PhyPacketProcessor.c PhyPlmeData.c PhyStateMachine.c PhyTime.c PhyTime.h
  group ieee_802.15.4/PHY/Source/MKW0x/SX123xDrv
    ../../../../../../../../ieee_802_15_4/Source/Phy/Source/MKW0x/SX123xDrv/: SX123xDrv.c SX123xDrv.h SX123xReg.h SX123xReg32MHz.h
  group ieee_802.15.4/PHY/Source/XcvrSPI
    ../../../../../../../../ieee_802_15_4/Source/Phy/Source/XcvrSpi/: Spi.c Spi.h
  group Source
    ../../../../common/: App.c App.h
    ../../: app_preinclude.h
  group KSDK
    ../../../../../../../../boards/usbkw019032_kw01/: board.c board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
