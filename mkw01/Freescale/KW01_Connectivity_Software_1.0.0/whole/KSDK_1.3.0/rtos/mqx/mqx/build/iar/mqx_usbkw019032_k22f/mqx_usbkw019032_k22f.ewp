# IAR project mqx_usbkw019032_k22f.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK22FN512VMP12=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/cpu; ../../../../../../platform/devices/MK22F51212/startup; ../../../../../../platform/CMSIS/Include; ../../../../config/common; ../../../../config/mcu/MK22F51212; ../../../../config/board/usbkw019032_k22f; ../../../../../../examples/usbkw019032_k22f; ../../../../../../platform/devices/MK22F51212; ../../../source/include; ../../../source/nio; ../../../source/nio/src; ../../../source/nio/fs; ../../../source/nio/drivers/nio_dummy; ../../../source/nio/drivers/nio_mem; ../../../source/nio/drivers/nio_null; ../../../source/nio/drivers/nio_pipe; ../../../source/nio/drivers/nio_serial; ../../../source/nio/drivers/nio_tfs; ../../../source/nio/drivers/nio_tty; ../../../../../../platform/devices/MK22F51212/startup; ../../../source/tad; ../../../source/include; ../../../../mqx_stdlib/source/include; ../../../../mqx_stdlib/source/stdio; ../../../../../../examples/usbkw019032_k22f; ../../../../../../platform/devices/MK22F51212/startup; ../../../../../../platform/devices/MK22F51212/include; ../../../../../../platform; ../../../../../../platform/devices; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../..; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/core/M4; ../../../source/psp/cortex_m; ../../../../../../platform/devices/MK22F51212/startup; ../../../../config/mcu/MK22F51212; ../../../../config/board/usbkw019032_k22f; ../../../../../../examples/usbkw019032_k22f; ../../../../../../platform/devices/MK22F51212; ../../../source/include; ../../../../config/common; ../../../../../../platform/devices/MK22F51212/startup; ../../../../../../examples/usbkw019032_k22f; ../../../../../../platform/devices/MK22F51212/startup; ../../../../../../platform/devices/MK22F51212/include
  postbuild: "../../bat/mqx_usbkw019032_k22f.bat" "../../../.." "../../../../lib/usbkw019032_k22f.iar/debug/mqx" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK22FN512VMP12=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: "../../bat/mqx_usbkw019032_k22f.bat" "../../../.." "../../../../lib/usbkw019032_k22f.iar/release/mqx" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group KSDK Files
    ../../../../../../platform/devices/MK22F51212/startup/iar/: startup_MK22F51212.s
    ../../../../../../platform/devices/MK22F51212/startup/: system_MK22F51212.c system_MK22F51212.h
    ../../../../../../platform/devices/: startup.c
  group MQX Generic/include
    ../../../source/psp/cortex_m/compiler/iar/: asm_mac.h comp.h comp.c
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h charq.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h tlsf.h tlsfbits.h tlsf_adaptation.h tlsf_adaptation_prv.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h tlsf.h tlsf_adaptation.h tlsf_adaptation_prv.h tlsfbits.h
  group MQX Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c lwsem.c mem.c tlsf.c tlsf_adaptation.c mqx.c sched.c task.c time.c taskq.c name.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c partition.c queue.c sem.c timer.c tlsf.c tlsf_adaptation.c watchdog.c
    ../../../source/include/: task.h
  group MQX Generic/nio
    ../../../source/nio/src/: nio.c nio_prv.h errno.c nio_std_adpt.c nio_posix.c
    ../../../source/nio/: nio.h unistd.h ioctl.h fcntl.h
    ../../../source/nio/fs/: fs_supp.c fs_supp.h
  group MQX Generic/string
    ../../../source/string/: strnlen.c str_utos.c
  group MQX Generic/tad
    ../../../source/tad/: tad.c tad.h
  group PSP Cortex
    ../../../source/psp/cortex_m/core/M4/: psp_prv.inc boot.S dispatch.S support.S
    ../../../source/psp/cortex_m/: types.inc int_gkis.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c psp.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h cortex.h kinetis_mpu.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h
  group CMSIS
    ../../../../../../platform/CMSIS/Include/: core_cm4.h core_cmSimd.h core_cmFunc.h core_cmInstr.h
  group Config Files
    ../../../../config/common/: small_ram_config.h lite_config.h verif_enabled_config.h mqx_cnfg.h
    ../../../../config/mcu/MK22F51212/: mqx_sdk_config.h
    ../../../../config/board/usbkw019032_k22f/: user_config.h
  group Peripheral NIO Drivers/nio_dummy
    ../../../source/nio/drivers/nio_dummy/src/: nio_dummy.c
    ../../../source/nio/drivers/nio_dummy/: nio_dummy.h
  group Peripheral NIO Drivers/nio_mem
    ../../../source/nio/drivers/nio_mem/src/: nio_mem.c
    ../../../source/nio/drivers/nio_mem/: nio_mem.h
  group Peripheral NIO Drivers/nio_null
    ../../../source/nio/drivers/nio_null/src/: nio_null.c
    ../../../source/nio/drivers/nio_null/: nio_null.h
  group Peripheral NIO Drivers/nio_pipe
    ../../../source/nio/drivers/nio_pipe/src/: nio_pipe.c
    ../../../source/nio/drivers/nio_pipe/: nio_pipe.h
  group Peripheral NIO Drivers/nio_serial
    ../../../source/nio/drivers/nio_serial/src/: nio_serial.c
    ../../../source/nio/drivers/nio_serial/: nio_serial.h
  group Peripheral NIO Drivers/nio_tfs
    ../../../source/nio/drivers/nio_tfs/src/: nio_tfs.c
    ../../../source/nio/drivers/nio_tfs/: nio_tfs.h
  group Peripheral NIO Drivers/nio_tty
    ../../../source/nio/drivers/nio_tty/src/: nio_tty.c
    ../../../source/nio/drivers/nio_tty/: nio_tty.h
