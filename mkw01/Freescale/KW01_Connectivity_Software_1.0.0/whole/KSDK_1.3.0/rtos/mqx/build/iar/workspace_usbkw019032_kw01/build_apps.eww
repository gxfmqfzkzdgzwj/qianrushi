<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>timer_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>test_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskq_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskat_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>sem_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>sem_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>nill_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>nill_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>mutex_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>msg_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>msg_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>log_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>log_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>klog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>klog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>isr_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>isr_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>hello_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>hello_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>event_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>event_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>demo_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>demo_usbkw019032_kw01</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>watchdog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>timer_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>timer_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>test_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>test_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskq_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskq_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskq_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskat_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>taskat_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>sem_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>sem_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>sem_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>sem_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>nill_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>nill_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>nill_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>nill_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>mutex_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>mutex_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>mutex_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>msg_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>msg_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>msg_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>msg_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwsem_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwlog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwevent_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>log_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>log_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>log_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>log_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>klog_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>klog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>klog_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>klog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>isr_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>isr_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>isr_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>isr_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>hello_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>hello_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>hello_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>hello_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>event_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>event_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>event_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>event_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>demo_lite_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>demo_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>demo_usbkw019032_kw01</project><configuration>int flash debug</configuration></member><member><project>demo_usbkw019032_kw01</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>watchdog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>timer_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>test_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskq_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskq_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>taskat_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>sem_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>sem_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>nill_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>nill_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>mutex_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>mutex_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>msg_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>msg_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwsem_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwlog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwevent_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>log_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>log_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>klog_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>klog_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>isr_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>isr_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>hello_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>hello_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>event_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>event_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>demo_lite_usbkw019032_kw01</project><configuration>int flash release</configuration></member><member><project>demo_usbkw019032_kw01</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog_lite\build\iar\watchdog_lite_usbkw019032_kw01\watchdog_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_usbkw019032_kw01\watchdog_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_usbkw019032_kw01\timer_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_usbkw019032_kw01\test_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq_lite\build\iar\taskq_lite_usbkw019032_kw01\taskq_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_usbkw019032_kw01\taskq_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_usbkw019032_kw01\taskat_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem_lite\build\iar\sem_lite_usbkw019032_kw01\sem_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_usbkw019032_kw01\sem_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill_lite\build\iar\nill_lite_usbkw019032_kw01\nill_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_usbkw019032_kw01\nill_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex_lite\build\iar\mutex_lite_usbkw019032_kw01\mutex_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_usbkw019032_kw01\mutex_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg_lite\build\iar\msg_lite_usbkw019032_kw01\msg_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_usbkw019032_kw01\msg_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem_lite\build\iar\lwsem_lite_usbkw019032_kw01\lwsem_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_usbkw019032_kw01\lwsem_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq_lite\build\iar\lwmsgq_lite_usbkw019032_kw01\lwmsgq_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_usbkw019032_kw01\lwmsgq_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog_lite\build\iar\lwlog_lite_usbkw019032_kw01\lwlog_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_usbkw019032_kw01\lwlog_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent_lite\build\iar\lwevent_lite_usbkw019032_kw01\lwevent_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_usbkw019032_kw01\lwevent_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_usbkw019032_kw01\lwdemo_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_usbkw019032_kw01\lwdemo_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log_lite\build\iar\log_lite_usbkw019032_kw01\log_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_usbkw019032_kw01\log_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog_lite\build\iar\klog_lite_usbkw019032_kw01\klog_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_usbkw019032_kw01\klog_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr_lite\build\iar\isr_lite_usbkw019032_kw01\isr_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_usbkw019032_kw01\isr_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_usbkw019032_kw01\hello_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_usbkw019032_kw01\hello_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event_lite\build\iar\event_lite_usbkw019032_kw01\event_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_usbkw019032_kw01\event_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo_lite\build\iar\demo_lite_usbkw019032_kw01\demo_lite_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_usbkw019032_kw01\demo_usbkw019032_kw01.ewp</path></project></workspace>
