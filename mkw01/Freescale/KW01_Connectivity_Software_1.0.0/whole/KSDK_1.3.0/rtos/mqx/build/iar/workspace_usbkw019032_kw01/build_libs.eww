<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_stdlib_usbkw019032_kw01</project><configuration>debug</configuration></member><member><project>nshell_usbkw019032_kw01</project><configuration>debug</configuration></member><member><project>mqx_usbkw019032_kw01</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>mqx_stdlib_usbkw019032_kw01</project><configuration>debug</configuration></member><member><project>mqx_stdlib_usbkw019032_kw01</project><configuration>release</configuration></member><member><project>nshell_usbkw019032_kw01</project><configuration>debug</configuration></member><member><project>nshell_usbkw019032_kw01</project><configuration>release</configuration></member><member><project>mqx_usbkw019032_kw01</project><configuration>debug</configuration></member><member><project>mqx_usbkw019032_kw01</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_stdlib_usbkw019032_kw01</project><configuration>release</configuration></member><member><project>nshell_usbkw019032_kw01</project><configuration>release</configuration></member><member><project>mqx_usbkw019032_kw01</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx_stdlib\build\iar\mqx_stdlib_usbkw019032_kw01\mqx_stdlib_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\nshell\build\iar\nshell_usbkw019032_kw01\nshell_usbkw019032_kw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\build\iar\mqx_usbkw019032_kw01\mqx_usbkw019032_kw01.ewp</path></project></workspace>
