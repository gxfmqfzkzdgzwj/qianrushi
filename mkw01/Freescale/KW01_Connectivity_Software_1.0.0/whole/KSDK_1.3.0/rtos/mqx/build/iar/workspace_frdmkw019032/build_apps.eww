<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>watchdog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>timer_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>test_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskq_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskat_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>sem_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>sem_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>nill_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>nill_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>mutex_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>msg_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>msg_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwsem_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwlog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwevent_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwdemo_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>log_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>log_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>klog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>klog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>isr_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>isr_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>hello_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>hello_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>event_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>event_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>demo_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>demo_frdmkw019032</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>watchdog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>watchdog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>watchdog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>timer_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>timer_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>test_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>test_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskq_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskq_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskq_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskat_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>taskat_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>sem_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>sem_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>sem_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>sem_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>nill_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>nill_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>nill_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>nill_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>mutex_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>mutex_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>mutex_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>msg_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>msg_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>msg_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>msg_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwsem_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwsem_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwmsgq_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwlog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwlog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwevent_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwevent_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwdemo_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>lwdemo_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>log_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>log_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>log_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>log_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>klog_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>klog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>klog_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>klog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>isr_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>isr_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>isr_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>isr_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>hello_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>hello_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>hello_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>hello_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>event_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>event_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>event_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>event_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>demo_lite_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>demo_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>demo_frdmkw019032</project><configuration>int flash debug</configuration></member><member><project>demo_frdmkw019032</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>watchdog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>timer_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>test_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskq_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskq_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>taskat_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>sem_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>sem_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>nill_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>nill_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>mutex_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>mutex_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>msg_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>msg_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwsem_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwmsgq_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwlog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwevent_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>lwdemo_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>log_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>log_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>klog_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>klog_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>isr_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>isr_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>hello_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>hello_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>event_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>event_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>demo_lite_frdmkw019032</project><configuration>int flash release</configuration></member><member><project>demo_frdmkw019032</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog_lite\build\iar\watchdog_lite_frdmkw019032\watchdog_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_frdmkw019032\watchdog_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_frdmkw019032\timer_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_frdmkw019032\test_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq_lite\build\iar\taskq_lite_frdmkw019032\taskq_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_frdmkw019032\taskq_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_frdmkw019032\taskat_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem_lite\build\iar\sem_lite_frdmkw019032\sem_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_frdmkw019032\sem_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill_lite\build\iar\nill_lite_frdmkw019032\nill_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_frdmkw019032\nill_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex_lite\build\iar\mutex_lite_frdmkw019032\mutex_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_frdmkw019032\mutex_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg_lite\build\iar\msg_lite_frdmkw019032\msg_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_frdmkw019032\msg_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem_lite\build\iar\lwsem_lite_frdmkw019032\lwsem_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_frdmkw019032\lwsem_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq_lite\build\iar\lwmsgq_lite_frdmkw019032\lwmsgq_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_frdmkw019032\lwmsgq_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog_lite\build\iar\lwlog_lite_frdmkw019032\lwlog_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_frdmkw019032\lwlog_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent_lite\build\iar\lwevent_lite_frdmkw019032\lwevent_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_frdmkw019032\lwevent_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_frdmkw019032\lwdemo_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_frdmkw019032\lwdemo_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log_lite\build\iar\log_lite_frdmkw019032\log_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_frdmkw019032\log_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog_lite\build\iar\klog_lite_frdmkw019032\klog_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_frdmkw019032\klog_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr_lite\build\iar\isr_lite_frdmkw019032\isr_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_frdmkw019032\isr_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_frdmkw019032\hello_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_frdmkw019032\hello_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event_lite\build\iar\event_lite_frdmkw019032\event_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_frdmkw019032\event_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo_lite\build\iar\demo_lite_frdmkw019032\demo_lite_frdmkw019032.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_frdmkw019032\demo_frdmkw019032.ewp</path></project></workspace>
