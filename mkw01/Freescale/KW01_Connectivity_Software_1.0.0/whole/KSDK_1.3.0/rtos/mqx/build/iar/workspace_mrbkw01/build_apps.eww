<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>watchdog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>timer_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>test_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskq_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskat_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>sem_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>sem_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>nill_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>nill_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>mutex_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>msg_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>msg_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>log_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>log_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>klog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>klog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>isr_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>isr_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>hello_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>hello_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>event_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>event_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>demo_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>demo_mrbkw01</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>watchdog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>watchdog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>watchdog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>timer_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>timer_mrbkw01</project><configuration>int flash release</configuration></member><member><project>test_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>test_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskq_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskq_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskq_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskq_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskat_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>taskat_mrbkw01</project><configuration>int flash release</configuration></member><member><project>sem_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>sem_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>sem_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>sem_mrbkw01</project><configuration>int flash release</configuration></member><member><project>nill_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>nill_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>nill_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>nill_mrbkw01</project><configuration>int flash release</configuration></member><member><project>mutex_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>mutex_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>mutex_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>mutex_mrbkw01</project><configuration>int flash release</configuration></member><member><project>msg_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>msg_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>msg_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>msg_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwsem_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwsem_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwmsgq_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwlog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwlog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwevent_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwevent_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>lwdemo_mrbkw01</project><configuration>int flash release</configuration></member><member><project>log_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>log_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>log_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>log_mrbkw01</project><configuration>int flash release</configuration></member><member><project>klog_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>klog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>klog_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>klog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>isr_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>isr_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>isr_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>isr_mrbkw01</project><configuration>int flash release</configuration></member><member><project>hello_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>hello_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>hello_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>hello_mrbkw01</project><configuration>int flash release</configuration></member><member><project>event_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>event_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>event_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>event_mrbkw01</project><configuration>int flash release</configuration></member><member><project>demo_lite_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>demo_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>demo_mrbkw01</project><configuration>int flash debug</configuration></member><member><project>demo_mrbkw01</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>watchdog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>watchdog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>timer_mrbkw01</project><configuration>int flash release</configuration></member><member><project>test_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskq_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskq_mrbkw01</project><configuration>int flash release</configuration></member><member><project>taskat_mrbkw01</project><configuration>int flash release</configuration></member><member><project>sem_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>sem_mrbkw01</project><configuration>int flash release</configuration></member><member><project>nill_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>nill_mrbkw01</project><configuration>int flash release</configuration></member><member><project>mutex_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>mutex_mrbkw01</project><configuration>int flash release</configuration></member><member><project>msg_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>msg_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwsem_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwsem_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwmsgq_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwlog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwlog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwevent_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwevent_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>lwdemo_mrbkw01</project><configuration>int flash release</configuration></member><member><project>log_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>log_mrbkw01</project><configuration>int flash release</configuration></member><member><project>klog_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>klog_mrbkw01</project><configuration>int flash release</configuration></member><member><project>isr_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>isr_mrbkw01</project><configuration>int flash release</configuration></member><member><project>hello_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>hello_mrbkw01</project><configuration>int flash release</configuration></member><member><project>event_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>event_mrbkw01</project><configuration>int flash release</configuration></member><member><project>demo_lite_mrbkw01</project><configuration>int flash release</configuration></member><member><project>demo_mrbkw01</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog_lite\build\iar\watchdog_lite_mrbkw01\watchdog_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_mrbkw01\watchdog_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_mrbkw01\timer_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_mrbkw01\test_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq_lite\build\iar\taskq_lite_mrbkw01\taskq_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_mrbkw01\taskq_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_mrbkw01\taskat_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem_lite\build\iar\sem_lite_mrbkw01\sem_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_mrbkw01\sem_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill_lite\build\iar\nill_lite_mrbkw01\nill_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_mrbkw01\nill_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex_lite\build\iar\mutex_lite_mrbkw01\mutex_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_mrbkw01\mutex_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg_lite\build\iar\msg_lite_mrbkw01\msg_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_mrbkw01\msg_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem_lite\build\iar\lwsem_lite_mrbkw01\lwsem_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_mrbkw01\lwsem_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq_lite\build\iar\lwmsgq_lite_mrbkw01\lwmsgq_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_mrbkw01\lwmsgq_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog_lite\build\iar\lwlog_lite_mrbkw01\lwlog_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_mrbkw01\lwlog_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent_lite\build\iar\lwevent_lite_mrbkw01\lwevent_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_mrbkw01\lwevent_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo_lite\build\iar\lwdemo_lite_mrbkw01\lwdemo_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_mrbkw01\lwdemo_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log_lite\build\iar\log_lite_mrbkw01\log_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_mrbkw01\log_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog_lite\build\iar\klog_lite_mrbkw01\klog_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_mrbkw01\klog_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr_lite\build\iar\isr_lite_mrbkw01\isr_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_mrbkw01\isr_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello_lite\build\iar\hello_lite_mrbkw01\hello_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_mrbkw01\hello_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event_lite\build\iar\event_lite_mrbkw01\event_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_mrbkw01\event_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo_lite\build\iar\demo_lite_mrbkw01\demo_lite_mrbkw01.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_mrbkw01\demo_mrbkw01.ewp</path></project></workspace>
