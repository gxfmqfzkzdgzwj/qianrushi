# Keil uVision project come.uvprojx, settings and files
target MKW01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKW01Z128xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.5.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: come +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKW01Z128CHN4   gPHY_802_15_4g_d gAspCapability_d  FSL_RTOS_FREE_RTOS
  c misc: --c99
  c include: .\KSDK_1.3.0\platform\CMSIS;.\KSDK_1.3.0\platform\devices\MKW01Z4;.\KSDK_1.3.0\platform\hal;.\KSDK_1.3.0\platform\drivers\src;.\KSDK_1.3.0\platform\drivers\src\spi;.\KSDK_1.3.0\platform\drivers\inc;.\KSDK_1.3.0\platform\devices\MKW01Z4\include;.\KSDK_1.3.0\platform\devices;D:\keilMDK\ARM\ARMCC\include;.\RTE\Device\MKW01Z128xxx4;D:\keilMDK\ARM\Pack\Keil\Kinetis_KWxx_DFP\1.5.0\Device\Include;D:\keilMDK\ARM\ARMCC\include;.\ConnSw\boards\frdmkw019032;.\KSDK_1.3.0\platform\system\inc;.\KSDK_1.3.0\platform\hal\src\sim\MKW01Z4;.\ConnSw\framework\Common;.\KSDK_1.3.0\platform\hal\inc;.\ConnSw\ieee_802_15_4\Source\Phy\Source\MKW0x;.\ConnSw\ieee_802_15_4\Source\Phy\Interface;.\ConnSw\framework\Messaging\Interface;.\ConnSw\framework\Lists;.\ConnSw\framework\MemManager\Interface;.\ConnSw\ieee_802_15_4\Source\Phy\Source\XcvrSpi;.\ConnSw\ieee_802_15_4\Source\Phy\Source\MKW0x\SX123xDrv;.\ConnSw\framework\FunctionLib;.\ConnSw\framework\Panic\Interface;.\ConnSw\framework\GPIOIrq;.\ConnSw\examples\ieee_802_15_4\MAC_FSCI_app\common;.\RTE\_MKW01
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group User
    ./ConnSw/ieee_802_15_4/Source/Phy/Source/MKW0x/: ASPtemp.c PhyExtended.c PhyPacketProcessor.c PhyPib.c PhyPlmeData.c PhyStateMachine.c PhyTime.c PhyISR.c PhyDebug.c thread.c
    ./ConnSw/ieee_802_15_4/Source/Phy/Source/MKW0x/SX123xDrv/: SX123xDrv.c
    ./ConnSw/examples/ieee_802_15_4/MAC_LE_Demo/Coordinator/common/: App.c
  group Driver
    ./ConnSw/ieee_802_15_4/Source/Phy/Source/XcvrSpi/: SPI.c
    ./ConnSw/boards/frdmkw019032/: gpio_pins.c pin_mux.c
    ./KSDK_1.3.0/platform/drivers/src/gpio/: fsl_gpio_driver.c
    ./KSDK_1.3.0/platform/hal/src/spi/: fsl_spi_hal.c
    ./KSDK_1.3.0/platform/hal/src/gpio/: fsl_gpio_hal.c
    ./KSDK_1.3.0/platform/hal/src/port/: fsl_port_hal.c
    ./KSDK_1.3.0/platform/system/src/clock/MKW01Z4/: fsl_clock_MKW01Z4.c
    ./KSDK_1.3.0/platform/hal/src/osc/: fsl_osc_hal.c
    ./KSDK_1.3.0/platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ./KSDK_1.3.0/platform/hal/src/sim/MKW01Z4/: fsl_sim_hal_MKW01Z4.c
    ./KSDK_1.3.0/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
  group Framework
    ./ConnSw/framework/Messaging/Source/: Messaging.c
    ./ConnSw/framework/MemManager/Source/: MemManager.c
    ./ConnSw/framework/Panic/Source/: Panic.c
    ./ConnSw/framework/FunctionLib/: FunctionLib.c
    ./ConnSw/framework/Lists/: GenericList.c
    ./KSDK_1.3.0/platform/drivers/src/tpm/: fsl_tpm_driver.c
    ./KSDK_1.3.0/platform/hal/src/tpm/: fsl_tpm_hal.c
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Coroutines 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.1, CMSIS:RTOS2:FreeRTOS 9.0.0, Device:Startup 1.0.0
